# Keil uVision project STM32L15X_bootloader_0.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L1xx_Medium_b0_V10000 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L1XX_MD
  c include: ..\Core;..\SysHard\include;..\User;..\..\Lib_Code\SysLib\include;..\..\Lib_Code\App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Core/: startup_stm32l1xx_md.s
  group App
    ../User/: main.c
  group Readme
    ../: readme.txt
