# Keil uVision project STM32L15x_bootloader_1.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L15x_Medium_b1_V10000 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L1XX_MD
  c include: ..\Core;..\SysHard\include;..\User;..\..\Lib_Code\SysLib\include;..\..\Lib_Code\App
  memory RVCT4: ROM 0x8000800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../Core/: system_stm32l1xx.c startup_stm32l1xx_md.s
  group SysLib
    ../../Lib_Code/SysLib/: BestFuLib.c CMDProcess.c CRC.c DeviceIDSetAttr.c DeviceUpgradeAttr.c Fifo.c FifoDataProc.c Object.c PhyMsgProc.c PivotalDataType.c SysExeAttr.c Thread.c Updata.c UserData.c MsgPackage.c Encode_lib.lib FaultManage.c Upload.c UnitShare_Attr.c DevPartTab.c
  group SysHard
    ../SysHard/: cpu.asm Program.c EEPROM.c flash.c gpio.c i2c.c iwdg.c spi.c sys.c SysHard.c SysTick.c usart.c SI4432.c Delay.c Instruct.c
  group App
    ../../Lib_Code/App/: main.c UnitCfg.c
  group Readme
    ../: readme.txt
